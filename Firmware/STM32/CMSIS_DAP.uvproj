# Keil uVision project CMSIS_DAP.uvproj, settings and files
target STM32-CDC (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_CDC +hex
  c flags: Optim=1
  c define: STM32F10X_MD BOARD_V1 USB_TEST
  c include: .\STM32F10x_Lib\inc;.\STM32F10x_Lib\src;.\CMSIS-DAP;.\USBStack\inc;.\USBStack\src;.\STM32F10x_Lib\rtl;.\Display
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ./CMSIS-DAP/: UserApp.c CMSIS_DAP.c CMSIS_Conf.c CMSIS_HID.c CMSIS_CDC.c CMSIS_ADC.c CMSIS_KEY.c CMSIS_LED.c SWD_WOW.c CMSIS_MX25L4006E.C
  group CMSIS-DAP
    ./CMSIS-DAP/: DAP.c SW_DP.c JTAG_DP.c
  group ISP
    ./CMSIS-DAP/: WOW_USART_BootLoader.c
  group HID
    ./USBStack/src/: usbd_core_hid.c usbd_hid.c
    ./CMSIS-DAP/: usbd_user_hid.c
  group CDC
    ./USBStack/src/: usbd_core_cdc.c usbd_cdc_acm.c
    ./CMSIS-DAP/: usbd_user_cdc_acm.c
  group MSC
    ./USBStack/src/: usbd_core_msc.c usbd_msc.c
  group USBStack
    ./CMSIS-DAP/: usb_Istr.c usb_config.c
  group USBLIB
    ./USBStack/src/: usbd_core.c usb_lib.c
  group Display
    ./Display/: oled.c sys.c delay.c
  group STM32F10x_Lib
    ./CMSIS-DAP/: system_stm32f10x.c
    ./STM32F10x_Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group DOC
    ./CMSIS-DAP/: SWD命令术语.txt 调试记录.txt
target USB_TEST (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: as above
  output: USB_TEST +hex
  c flags: Optim=1
  c define: STM32F10X_MD BOARD_V1  USB_TEST
  c include: .\STM32F10x_Lib\inc;.\STM32F10x_Lib\src;.\CMSIS-DAP;.\USBStack\inc;.\USBStack\src;.\STM32F10x_Lib\rtl;.\Display;.\STM32_USB-FS-Device_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target SWD_TEST (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: as above
  output: CMSIS_TEST +hex
  c flags: Optim=1
  c define: STM32F10X_MD BOARD_V1  CMSIS_TEST SWD_TEST
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
